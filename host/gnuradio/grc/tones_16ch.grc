options:
  parameters:
    description: 16-channel timed tone bursts, captured on every channel (any board with 16-channel builds)
    generate_options: qt_gui
    id: tones_16ch
    output_language: python
    run_command: /bin/bash -c 'exec pkexec env DISPLAY="$DISPLAY" XAUTHORITY="$XAUTHORITY" /usr/local/bin/uhd-rfsoc "$0" -u "$1"' {python} {filename}
    title: 16ch tones (otw sc16, default 156.25 MS/s), TX phase / amplitude per channel
  states: {}

blocks:
- name: burst_len
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: cap_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: cap_offset
  id: variable
  parameters:
    value: burst_len // 4
  states: {}
- name: dev_args
  id: variable
  parameters:
    value: '"type=rfsoc,channels=16" + (",addr=" + addr if addr else "")'
  states: {}
- name: lead
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: nchan
  id: variable
  parameters:
    value: '16'
  states: {}
- name: period
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: per-channel sample rate (S/s; the daemon serves the highest at or below it)
    short_id: r
    type: eng_float
    value: '1.5625e+08'
  states: {}
- name: tx_amp0
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@1: 0,0,1,1'
    label: ch 0
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: tx_amp_init[0]
  states: {}
- name: tx_amp1
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@1: 0,1,1,1'
    label: ch 1
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: tx_amp_init[1]
  states: {}
- name: tx_amp10
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@1: 2,2,1,1'
    label: ch 10
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: tx_amp_init[10]
  states: {}
- name: tx_amp11
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@1: 2,3,1,1'
    label: ch 11
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: tx_amp_init[11]
  states: {}
- name: tx_amp12
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@1: 3,0,1,1'
    label: ch 12
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: tx_amp_init[12]
  states: {}
- name: tx_amp13
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@1: 3,1,1,1'
    label: ch 13
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: tx_amp_init[13]
  states: {}
- name: tx_amp14
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@1: 3,2,1,1'
    label: ch 14
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: tx_amp_init[14]
  states: {}
- name: tx_amp15
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@1: 3,3,1,1'
    label: ch 15
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: tx_amp_init[15]
  states: {}
- name: tx_amp2
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@1: 0,2,1,1'
    label: ch 2
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: tx_amp_init[2]
  states: {}
- name: tx_amp3
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@1: 0,3,1,1'
    label: ch 3
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: tx_amp_init[3]
  states: {}
- name: tx_amp4
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@1: 1,0,1,1'
    label: ch 4
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: tx_amp_init[4]
  states: {}
- name: tx_amp5
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@1: 1,1,1,1'
    label: ch 5
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: tx_amp_init[5]
  states: {}
- name: tx_amp6
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@1: 1,2,1,1'
    label: ch 6
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: tx_amp_init[6]
  states: {}
- name: tx_amp7
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@1: 1,3,1,1'
    label: ch 7
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: tx_amp_init[7]
  states: {}
- name: tx_amp8
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@1: 2,0,1,1'
    label: ch 8
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: tx_amp_init[8]
  states: {}
- name: tx_amp9
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@1: 2,1,1,1'
    label: ch 9
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: tx_amp_init[9]
  states: {}
- name: tx_amp_init
  id: variable
  parameters:
    value: '[float(x) for x in (tx_amps.split(",") + ["0.25"] * nchan)[:nchan]]'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: tx_ph0
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@0: 0,0,1,1'
    label: ch 0
    min_len: '100'
    start: '-180'
    step: '0.1'
    stop: '180'
    value: tx_phase_init[0]
  states: {}
- name: tx_ph1
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@0: 0,1,1,1'
    label: ch 1
    min_len: '100'
    start: '-180'
    step: '0.1'
    stop: '180'
    value: tx_phase_init[1]
  states: {}
- name: tx_ph10
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@0: 2,2,1,1'
    label: ch 10
    min_len: '100'
    start: '-180'
    step: '0.1'
    stop: '180'
    value: tx_phase_init[10]
  states: {}
- name: tx_ph11
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@0: 2,3,1,1'
    label: ch 11
    min_len: '100'
    start: '-180'
    step: '0.1'
    stop: '180'
    value: tx_phase_init[11]
  states: {}
- name: tx_ph12
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@0: 3,0,1,1'
    label: ch 12
    min_len: '100'
    start: '-180'
    step: '0.1'
    stop: '180'
    value: tx_phase_init[12]
  states: {}
- name: tx_ph13
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@0: 3,1,1,1'
    label: ch 13
    min_len: '100'
    start: '-180'
    step: '0.1'
    stop: '180'
    value: tx_phase_init[13]
  states: {}
- name: tx_ph14
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@0: 3,2,1,1'
    label: ch 14
    min_len: '100'
    start: '-180'
    step: '0.1'
    stop: '180'
    value: tx_phase_init[14]
  states: {}
- name: tx_ph15
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@0: 3,3,1,1'
    label: ch 15
    min_len: '100'
    start: '-180'
    step: '0.1'
    stop: '180'
    value: tx_phase_init[15]
  states: {}
- name: tx_ph2
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@0: 0,2,1,1'
    label: ch 2
    min_len: '100'
    start: '-180'
    step: '0.1'
    stop: '180'
    value: tx_phase_init[2]
  states: {}
- name: tx_ph3
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@0: 0,3,1,1'
    label: ch 3
    min_len: '100'
    start: '-180'
    step: '0.1'
    stop: '180'
    value: tx_phase_init[3]
  states: {}
- name: tx_ph4
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@0: 1,0,1,1'
    label: ch 4
    min_len: '100'
    start: '-180'
    step: '0.1'
    stop: '180'
    value: tx_phase_init[4]
  states: {}
- name: tx_ph5
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@0: 1,1,1,1'
    label: ch 5
    min_len: '100'
    start: '-180'
    step: '0.1'
    stop: '180'
    value: tx_phase_init[5]
  states: {}
- name: tx_ph6
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@0: 1,2,1,1'
    label: ch 6
    min_len: '100'
    start: '-180'
    step: '0.1'
    stop: '180'
    value: tx_phase_init[6]
  states: {}
- name: tx_ph7
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@0: 1,3,1,1'
    label: ch 7
    min_len: '100'
    start: '-180'
    step: '0.1'
    stop: '180'
    value: tx_phase_init[7]
  states: {}
- name: tx_ph8
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@0: 2,0,1,1'
    label: ch 8
    min_len: '100'
    start: '-180'
    step: '0.1'
    stop: '180'
    value: tx_phase_init[8]
  states: {}
- name: tx_ph9
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl@0: 2,1,1,1'
    label: ch 9
    min_len: '100'
    start: '-180'
    step: '0.1'
    stop: '180'
    value: tx_phase_init[9]
  states: {}
- name: tx_phase_init
  id: variable
  parameters:
    value: '[float(x) for x in (tx_phases.split(",") + ["0"] * nchan)[:nchan]]'
  states: {}
- name: addr
  id: parameter
  parameters:
    label: 'board address (empty: discover)'
    type: str
    value: ''
  states: {}
- name: bursts
  id: snippet
  parameters:
    code: |
      from PyQt5 import Qt as _Qt
      # open on the TX phase sliders: after show(), which focuses a slider and so its tab
      _Qt.QTimer.singleShot(200, lambda tb=self: tb.ctrl.setCurrentIndex(0))
      import os, threading, time as _time
      import pmt
      from gnuradio import uhd as _uhd
      from PyQt5 import Qt as _Qt
      # burst mode: stop the continuous stream gr-uhd starts with the flowgraph, then
      # every period one TX burst at device time t0 and one RX capture inside it
      _src = self.usrp_source
      _src.issue_stream_cmd(_uhd.stream_cmd_t(_uhd.STREAM_MODE_STOP_CONTINUOUS))
      self.bursts_sent = 0
      def _bursts(tb=self):
          _time.sleep(2.0)   # let the flowgraph and the GUI settle: the first bursts were late
          while True:
              t0 = _src.get_time_now().get_real_secs() + tb.lead
              tb.tones._post(pmt.intern("fire"), pmt.from_double(t0))
              cmd = _uhd.stream_cmd_t(_uhd.STREAM_MODE_NUM_SAMPS_AND_DONE)
              cmd.num_samps = tb.cap_len
              cmd.stream_now = False
              cmd.time_spec = _uhd.time_spec(t0 + tb.cap_offset / tb.samp_rate)
              _src.issue_stream_cmd(cmd)
              tb.bursts_sent += 1
              _time.sleep(tb.period)
      threading.Thread(target=_bursts, daemon=True).start()
      # UHD_RFSOC_GR_SNAPSHOT=<png>: save the window after UHD_RFSOC_GR_SNAPSHOT_S (default 6) s and quit
      _snap = os.environ.get("UHD_RFSOC_GR_SNAPSHOT")
      if _snap:
          self.resize(1600, 600)
          def _shot(tb=self):
              tb.grab().save(_snap)
              print(f"snapshot {_snap} after {tb.bursts_sent} bursts", flush=True)
              tb.close()
          _Qt.QTimer.singleShot(int(1000 * float(os.environ.get("UHD_RFSOC_GR_SNAPSHOT_S", "6"))), _shot)
    section: main_after_start
  states: {}
- name: ctrl
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,1
    label0: TX phase (deg)
    label1: TX amplitude (0-1, full scale 1)
    num_tabs: '2'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: RF centre (Hz)
    short_id: f
    type: eng_float
    value: '9.5e+08'
  states: {}
- name: spec0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 'tabs@0: 0,1,1,1'
    label1: '"RX 0"'
    label2: '"RX 1"'
    label3: '"RX 2"'
    label4: '"RX 3"'
    name: '"RX 0-3: spectrum"'
    nconnections: '4'
    type: complex
    ymax: '0'
    ymin: '-130'
  states: {}
- name: spec1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 'tabs@1: 0,1,1,1'
    label1: '"RX 4"'
    label2: '"RX 5"'
    label3: '"RX 6"'
    label4: '"RX 7"'
    name: '"RX 4-7: spectrum"'
    nconnections: '4'
    type: complex
    ymax: '0'
    ymin: '-130'
  states: {}
- name: spec2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 'tabs@2: 0,1,1,1'
    label1: '"RX 8"'
    label2: '"RX 9"'
    label3: '"RX 10"'
    label4: '"RX 11"'
    name: '"RX 8-11: spectrum"'
    nconnections: '4'
    type: complex
    ymax: '0'
    ymin: '-130'
  states: {}
- name: spec3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 'tabs@3: 0,1,1,1'
    label1: '"RX 12"'
    label2: '"RX 13"'
    label3: '"RX 14"'
    label4: '"RX 15"'
    name: '"RX 12-15: spectrum"'
    nconnections: '4'
    type: complex
    ymax: '0'
    ymin: '-130'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,1
    label0: RX 0-3
    label1: RX 4-7
    label2: RX 8-11
    label3: RX 12-15
    num_tabs: '4'
  states: {}
- name: time0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color2: blue
    color3: red
    color4: red
    color5: green
    color6: green
    color7: black
    color8: black
    entags: 'False'
    grid: 'True'
    gui_hint: 'tabs@0: 0,0,1,1'
    label1: '"RX 0 Re"'
    label2: '"RX 0 Im"'
    label3: '"RX 1 Re"'
    label4: '"RX 1 Im"'
    label5: '"RX 2 Re"'
    label6: '"RX 2 Im"'
    label7: '"RX 3 Re"'
    label8: '"RX 3 Im"'
    name: '"RX 0-3: real (solid) and imaginary (dashed) part"'
    nconnections: '4'
    size: '512'
    srate: samp_rate
    style2: '2'
    style4: '2'
    style6: '2'
    style8: '2'
    type: complex
  states: {}
- name: time1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color2: blue
    color3: red
    color4: red
    color5: green
    color6: green
    color7: black
    color8: black
    entags: 'False'
    grid: 'True'
    gui_hint: 'tabs@1: 0,0,1,1'
    label1: '"RX 4 Re"'
    label2: '"RX 4 Im"'
    label3: '"RX 5 Re"'
    label4: '"RX 5 Im"'
    label5: '"RX 6 Re"'
    label6: '"RX 6 Im"'
    label7: '"RX 7 Re"'
    label8: '"RX 7 Im"'
    name: '"RX 4-7: real (solid) and imaginary (dashed) part"'
    nconnections: '4'
    size: '512'
    srate: samp_rate
    style2: '2'
    style4: '2'
    style6: '2'
    style8: '2'
    type: complex
  states: {}
- name: time2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color2: blue
    color3: red
    color4: red
    color5: green
    color6: green
    color7: black
    color8: black
    entags: 'False'
    grid: 'True'
    gui_hint: 'tabs@2: 0,0,1,1'
    label1: '"RX 8 Re"'
    label2: '"RX 8 Im"'
    label3: '"RX 9 Re"'
    label4: '"RX 9 Im"'
    label5: '"RX 10 Re"'
    label6: '"RX 10 Im"'
    label7: '"RX 11 Re"'
    label8: '"RX 11 Im"'
    name: '"RX 8-11: real (solid) and imaginary (dashed) part"'
    nconnections: '4'
    size: '512'
    srate: samp_rate
    style2: '2'
    style4: '2'
    style6: '2'
    style8: '2'
    type: complex
  states: {}
- name: time3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color2: blue
    color3: red
    color4: red
    color5: green
    color6: green
    color7: black
    color8: black
    entags: 'False'
    grid: 'True'
    gui_hint: 'tabs@3: 0,0,1,1'
    label1: '"RX 12 Re"'
    label2: '"RX 12 Im"'
    label3: '"RX 13 Re"'
    label4: '"RX 13 Im"'
    label5: '"RX 14 Re"'
    label6: '"RX 14 Im"'
    label7: '"RX 15 Re"'
    label8: '"RX 15 Im"'
    name: '"RX 12-15: real (solid) and imaginary (dashed) part"'
    nconnections: '4'
    size: '512'
    srate: samp_rate
    style2: '2'
    style4: '2'
    style6: '2'
    style8: '2'
    type: complex
  states: {}
- name: tone
  id: parameter
  parameters:
    label: tone above the RF centre (Hz)
    short_id: t
    type: eng_float
    value: '1e+07'
  states: {}
- name: tones
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python block (GRC epy_block) of the tones_* flowgraphs:
      one timed TX burst per message on the `fire` port, the same tone on every
      channel, each with its own phase and amplitude (`phases_deg`, `amps`).

      Channel k carries amps[k] x exp(j phases_deg[k] pi / 180) x exp(j 2 pi tone_step n) (tone_step: the tone as
      a fraction of the sample rate; the flowgraphs pass tone / samp_rate, 10 MHz
      by default). A message on `fire` (a pmt
      double: the device time t0, seconds) queues one burst of `burst_len` samples
      per channel, tagged for gr-uhd's USRP Sink on output 0: tx_sob + tx_time (t0)
      on its first sample, tx_eob on its last. Between bursts the block emits
      nothing, so the sink sends nothing.

      The burst is requested by message, not by a method call, because a message
      wakes the block's thread at once: a source block that returned 0 items is
      otherwise left idle for up to 250 ms by GNU Radio's scheduler, which made the
      burst miss its start time (late packet, then an underflow per packet).

      The block's very first output is one zero sample tagged tx_eob. gr-uhd's USRP
      Sink opens a timed burst when it starts (an empty start-of-burst packet at
      now + 0.15 s) and never ends it; left open, the first real burst would close
      it with a packet whose time has passed -- a late (L) event. Ending it at once,
      well before its time, plays one zero sample and reports nothing.
      """
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, nchan=16, burst_len=32768, amp=0.25, tone_step=1.0 / 64,
                       phases_deg=(), amps=()):
              gr.sync_block.__init__(self, name="RFSoC tone bursts", in_sig=None,
                                     out_sig=[np.complex64] * int(nchan))
              self.nchan, self.burst_len = int(nchan), int(burst_len)
              n = np.arange(self.burst_len)
              self._tone = np.exp(2j * np.pi * tone_step * n)
              # per-channel TX phase (degrees) and amplitude (fraction of full scale):
              # plain attributes, so GRC's callbacks (the flowgraph's sliders) set them
              # while it runs; a burst uses the values in force when it starts.
              # Missing entries: 0 degrees, amplitude `amp`.
              self.amp = float(amp)
              self.phases_deg = phases_deg
              self.amps = amps
              self._key, self._sigs, self._cur = None, None, None
              self.message_port_register_in(pmt.intern("fire"))
              self.set_msg_handler(pmt.intern("fire"), self._fire)
              self._pending = []
              self._pos = None
              self._t0 = 0.0
              self._closed_start = False

          def _fire(self, msg):
              self._pending.append(pmt.to_double(msg))

          def _channel_sigs(self):
              ph = [float(x) for x in self.phases_deg][:self.nchan]
              am = [float(x) for x in self.amps][:self.nchan]
              ph += [0.0] * (self.nchan - len(ph))
              am += [self.amp] * (self.nchan - len(am))
              key = (tuple(ph), tuple(am))
              if key != self._key:
                  self._key = key
                  self._sigs = [(am[k] * np.exp(1j * np.deg2rad(ph[k])) * self._tone).astype(np.complex64)
                                for k in range(self.nchan)]
              return self._sigs

          def work(self, input_items, output_items):
              if not self._closed_start:
                  # end gr-uhd's start-of-stream burst (see the module docstring)
                  self._closed_start = True
                  for k in range(self.nchan):
                      output_items[k][0] = 0
                  self.add_item_tag(0, self.nitems_written(0), pmt.intern("tx_eob"), pmt.PMT_T)
                  return 1
              if self._pos is None:
                  if not self._pending:
                      return 0
                  self._t0, self._pos = self._pending.pop(0), 0
                  self._cur = self._channel_sigs()
              pos = self._pos
              n = min(len(output_items[0]), self.burst_len - pos)
              for k in range(self.nchan):
                  output_items[k][:n] = self._cur[k][pos:pos + n]
              off = self.nitems_written(0)
              if pos == 0:
                  secs = int(self._t0)
                  self.add_item_tag(0, off, pmt.intern("tx_sob"), pmt.PMT_T)
                  self.add_item_tag(0, off, pmt.intern("tx_time"),
                                    pmt.make_tuple(pmt.from_uint64(secs), pmt.from_double(self._t0 - secs)))
              if pos + n == self.burst_len:
                  self.add_item_tag(0, off + n - 1, pmt.intern("tx_eob"), pmt.PMT_T)
                  self._pos = None
              else:
                  self._pos = pos + n
              return n
    amp: '0.25'
    amps: '[tx_amp0, tx_amp1, tx_amp2, tx_amp3, tx_amp4, tx_amp5, tx_amp6, tx_amp7, tx_amp8, tx_amp9, tx_amp10, tx_amp11, tx_amp12, tx_amp13, tx_amp14, tx_amp15]'
    burst_len: burst_len
    nchan: nchan
    phases_deg: '[tx_ph0, tx_ph1, tx_ph2, tx_ph3, tx_ph4, tx_ph5, tx_ph6, tx_ph7, tx_ph8, tx_ph9, tx_ph10, tx_ph11, tx_ph12, tx_ph13, tx_ph14, tx_ph15]'
    tone_step: tone / samp_rate
  states: {}
- name: tx_amps
  id: parameter
  parameters:
    label: TX amplitude per channel (0-1, comma-separated)
    type: str
    value: 0.25,0.25,0.25,0.25,0.25,0.25,0.25,0.25,0.25,0.25,0.25,0.25,0.25,0.25,0.25,0.25
  states: {}
- name: tx_phases
  id: parameter
  parameters:
    label: TX phase per channel (deg, comma-separated)
    type: str
    value: 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0
  states: {}
- name: usrp_sink
  id: uhd_usrp_sink
  parameters:
    ant0: '""'
    ant1: '""'
    ant10: '""'
    ant11: '""'
    ant12: '""'
    ant13: '""'
    ant14: '""'
    ant15: '""'
    ant2: '""'
    ant3: '""'
    ant4: '""'
    ant5: '""'
    ant6: '""'
    ant7: '""'
    ant8: '""'
    ant9: '""'
    center_freq0: freq
    center_freq1: freq
    center_freq10: freq
    center_freq11: freq
    center_freq12: freq
    center_freq13: freq
    center_freq14: freq
    center_freq15: freq
    center_freq2: freq
    center_freq3: freq
    center_freq4: freq
    center_freq5: freq
    center_freq6: freq
    center_freq7: freq
    center_freq8: freq
    center_freq9: freq
    dev_addr: dev_args
    dev_args: '""'
    gain0: tx_gain
    gain1: tx_gain
    gain10: tx_gain
    gain11: tx_gain
    gain12: tx_gain
    gain13: tx_gain
    gain14: tx_gain
    gain15: tx_gain
    gain2: tx_gain
    gain3: tx_gain
    gain4: tx_gain
    gain5: tx_gain
    gain6: tx_gain
    gain7: tx_gain
    gain8: tx_gain
    gain9: tx_gain
    nchan: nchan
    otw: sc16
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: '""'
    ant1: '""'
    ant10: '""'
    ant11: '""'
    ant12: '""'
    ant13: '""'
    ant14: '""'
    ant15: '""'
    ant2: '""'
    ant3: '""'
    ant4: '""'
    ant5: '""'
    ant6: '""'
    ant7: '""'
    ant8: '""'
    ant9: '""'
    center_freq0: freq
    center_freq1: freq
    center_freq10: freq
    center_freq11: freq
    center_freq12: freq
    center_freq13: freq
    center_freq14: freq
    center_freq15: freq
    center_freq2: freq
    center_freq3: freq
    center_freq4: freq
    center_freq5: freq
    center_freq6: freq
    center_freq7: freq
    center_freq8: freq
    center_freq9: freq
    dev_addr: dev_args
    dev_args: '""'
    gain0: rx_gain
    gain1: rx_gain
    gain10: rx_gain
    gain11: rx_gain
    gain12: rx_gain
    gain13: rx_gain
    gain14: rx_gain
    gain15: rx_gain
    gain2: rx_gain
    gain3: rx_gain
    gain4: rx_gain
    gain5: rx_gain
    gain6: rx_gain
    gain7: rx_gain
    gain8: rx_gain
    gain9: rx_gain
    nchan: nchan
    otw: sc16
    rx_agc10: Default
    rx_agc11: Default
    rx_agc12: Default
    rx_agc13: Default
    rx_agc14: Default
    rx_agc15: Default
    rx_agc2: Default
    rx_agc3: Default
    rx_agc4: Default
    rx_agc5: Default
    rx_agc6: Default
    rx_agc7: Default
    rx_agc8: Default
    rx_agc9: Default
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [tones, '0', usrp_sink, '0']
- [tones, '1', usrp_sink, '1']
- [tones, '10', usrp_sink, '10']
- [tones, '11', usrp_sink, '11']
- [tones, '12', usrp_sink, '12']
- [tones, '13', usrp_sink, '13']
- [tones, '14', usrp_sink, '14']
- [tones, '15', usrp_sink, '15']
- [tones, '2', usrp_sink, '2']
- [tones, '3', usrp_sink, '3']
- [tones, '4', usrp_sink, '4']
- [tones, '5', usrp_sink, '5']
- [tones, '6', usrp_sink, '6']
- [tones, '7', usrp_sink, '7']
- [tones, '8', usrp_sink, '8']
- [tones, '9', usrp_sink, '9']
- [usrp_source, '0', spec0, '0']
- [usrp_source, '0', time0, '0']
- [usrp_source, '1', spec0, '1']
- [usrp_source, '1', time0, '1']
- [usrp_source, '10', spec2, '2']
- [usrp_source, '10', time2, '2']
- [usrp_source, '11', spec2, '3']
- [usrp_source, '11', time2, '3']
- [usrp_source, '12', spec3, '0']
- [usrp_source, '12', time3, '0']
- [usrp_source, '13', spec3, '1']
- [usrp_source, '13', time3, '1']
- [usrp_source, '14', spec3, '2']
- [usrp_source, '14', time3, '2']
- [usrp_source, '15', spec3, '3']
- [usrp_source, '15', time3, '3']
- [usrp_source, '2', spec0, '2']
- [usrp_source, '2', time0, '2']
- [usrp_source, '3', spec0, '3']
- [usrp_source, '3', time0, '3']
- [usrp_source, '4', spec1, '0']
- [usrp_source, '4', time1, '0']
- [usrp_source, '5', spec1, '1']
- [usrp_source, '5', time1, '1']
- [usrp_source, '6', spec1, '2']
- [usrp_source, '6', time1, '2']
- [usrp_source, '7', spec1, '3']
- [usrp_source, '7', time1, '3']
- [usrp_source, '8', spec2, '0']
- [usrp_source, '8', time2, '0']
- [usrp_source, '9', spec2, '1']
- [usrp_source, '9', time2, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
