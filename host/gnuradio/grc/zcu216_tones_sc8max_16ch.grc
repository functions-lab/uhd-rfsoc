options:
  parameters:
    description: 'ZCU216 sc8max 16ch (zcu216_v49_16ch_qsfp_f8_fs2500): timed tone bursts, captured on every channel'
    generate_options: qt_gui
    id: zcu216_tones_sc8max_16ch
    output_language: python
    run_command: /bin/bash -c 'exec pkexec env DISPLAY="$DISPLAY" XAUTHORITY="$XAUTHORITY" /usr/local/bin/zcu216-uhd "$0" -u "$1"' {python} {filename}
    title: ZCU216 sc8max 16ch tones (312.5 MS/s, otw sc8)
  states: {}

blocks:
- name: burst_len
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: cap_len
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: cap_offset
  id: variable
  parameters:
    value: burst_len // 4
  states: {}
- name: dev_args
  id: variable
  parameters:
    value: '"type=zcu216,product=zcu216,channels=16" + ",otw=sc8" + (",addr=" + addr if addr else "")'
  states: {}
- name: lead
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: nchan
  id: variable
  parameters:
    value: '16'
  states: {}
- name: period
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3.125e+08'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: addr
  id: parameter
  parameters:
    label: 'board address (empty: discover)'
    type: str
    value: ''
  states: {}
- name: bursts
  id: snippet
  parameters:
    code: |
      import os, threading, time as _time
      import pmt
      from gnuradio import uhd as _uhd
      from PyQt5 import Qt as _Qt
      # burst mode: stop the continuous stream gr-uhd starts with the flowgraph, then
      # every period one TX burst at device time t0 and one RX capture inside it
      _src = self.usrp_source
      _src.issue_stream_cmd(_uhd.stream_cmd_t(_uhd.STREAM_MODE_STOP_CONTINUOUS))
      self.bursts_sent = 0
      def _bursts(tb=self):
          _time.sleep(2.0)   # let the flowgraph and the GUI settle: the first bursts were late
          while True:
              t0 = _src.get_time_now().get_real_secs() + tb.lead
              tb.tones._post(pmt.intern("fire"), pmt.from_double(t0))
              cmd = _uhd.stream_cmd_t(_uhd.STREAM_MODE_NUM_SAMPS_AND_DONE)
              cmd.num_samps = tb.cap_len
              cmd.stream_now = False
              cmd.time_spec = _uhd.time_spec(t0 + tb.cap_offset / tb.samp_rate)
              _src.issue_stream_cmd(cmd)
              tb.bursts_sent += 1
              _time.sleep(tb.period)
      threading.Thread(target=_bursts, daemon=True).start()
      # ZCU216_GR_SNAPSHOT=<png>: save the window after ZCU216_GR_SNAPSHOT_S (default 6) s and quit
      _snap = os.environ.get("ZCU216_GR_SNAPSHOT")
      if _snap:
          self.resize(1600, 600)
          def _shot(tb=self):
              tb.grab().save(_snap)
              print(f"snapshot {_snap} after {tb.bursts_sent} bursts", flush=True)
              tb.close()
          _Qt.QTimer.singleShot(int(1000 * float(os.environ.get("ZCU216_GR_SNAPSHOT_S", "6"))), _shot)
    section: main_after_start
  states: {}
- name: freq
  id: parameter
  parameters:
    label: RF centre (Hz)
    short_id: f
    type: eng_float
    value: '9.5e+08'
  states: {}
- name: spec0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 'tabs@0: 0,1,1,1'
    label1: '"RX 0"'
    label2: '"RX 1"'
    label3: '"RX 2"'
    label4: '"RX 3"'
    name: '"RX 0-3: spectrum"'
    nconnections: '4'
    type: complex
    ymax: '0'
    ymin: '-130'
  states: {}
- name: spec1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 'tabs@1: 0,1,1,1'
    label1: '"RX 4"'
    label2: '"RX 5"'
    label3: '"RX 6"'
    label4: '"RX 7"'
    name: '"RX 4-7: spectrum"'
    nconnections: '4'
    type: complex
    ymax: '0'
    ymin: '-130'
  states: {}
- name: spec2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 'tabs@2: 0,1,1,1'
    label1: '"RX 8"'
    label2: '"RX 9"'
    label3: '"RX 10"'
    label4: '"RX 11"'
    name: '"RX 8-11: spectrum"'
    nconnections: '4'
    type: complex
    ymax: '0'
    ymin: '-130'
  states: {}
- name: spec3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 'tabs@3: 0,1,1,1'
    label1: '"RX 12"'
    label2: '"RX 13"'
    label3: '"RX 14"'
    label4: '"RX 15"'
    name: '"RX 12-15: spectrum"'
    nconnections: '4'
    type: complex
    ymax: '0'
    ymin: '-130'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,1
    label0: RX 0-3
    label1: RX 4-7
    label2: RX 8-11
    label3: RX 12-15
    num_tabs: '4'
  states: {}
- name: time0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 'tabs@0: 0,0,1,1'
    label1: '"RX 0 I"'
    label2: '"RX 0 Q"'
    label3: '"RX 1 I"'
    label4: '"RX 1 Q"'
    label5: '"RX 2 I"'
    label6: '"RX 2 Q"'
    label7: '"RX 3 I"'
    label8: '"RX 3 Q"'
    name: '"RX 0-3: time"'
    nconnections: '4'
    size: '512'
    srate: samp_rate
    type: complex
  states: {}
- name: time1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 'tabs@1: 0,0,1,1'
    label1: '"RX 4 I"'
    label2: '"RX 4 Q"'
    label3: '"RX 5 I"'
    label4: '"RX 5 Q"'
    label5: '"RX 6 I"'
    label6: '"RX 6 Q"'
    label7: '"RX 7 I"'
    label8: '"RX 7 Q"'
    name: '"RX 4-7: time"'
    nconnections: '4'
    size: '512'
    srate: samp_rate
    type: complex
  states: {}
- name: time2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 'tabs@2: 0,0,1,1'
    label1: '"RX 8 I"'
    label2: '"RX 8 Q"'
    label3: '"RX 9 I"'
    label4: '"RX 9 Q"'
    label5: '"RX 10 I"'
    label6: '"RX 10 Q"'
    label7: '"RX 11 I"'
    label8: '"RX 11 Q"'
    name: '"RX 8-11: time"'
    nconnections: '4'
    size: '512'
    srate: samp_rate
    type: complex
  states: {}
- name: time3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 'tabs@3: 0,0,1,1'
    label1: '"RX 12 I"'
    label2: '"RX 12 Q"'
    label3: '"RX 13 I"'
    label4: '"RX 13 Q"'
    label5: '"RX 14 I"'
    label6: '"RX 14 Q"'
    label7: '"RX 15 I"'
    label8: '"RX 15 Q"'
    name: '"RX 12-15: time"'
    nconnections: '4'
    size: '512'
    srate: samp_rate
    type: complex
  states: {}
- name: tone
  id: parameter
  parameters:
    label: tone above the RF centre (Hz)
    short_id: t
    type: eng_float
    value: '1e+07'
  states: {}
- name: tones
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python block (GRC epy_block) of the zcu216_tones_* flowgraphs:
      one timed TX burst per message on the `fire` port, the same tone on every
      channel.

      Every channel carries amp x exp(j 2 pi tone_step n) (tone_step: the tone as
      a fraction of the sample rate; the flowgraphs pass tone / samp_rate, 10 MHz
      by default). A message on `fire` (a pmt
      double: the device time t0, seconds) queues one burst of `burst_len` samples
      per channel, tagged for gr-uhd's USRP Sink on output 0: tx_sob + tx_time (t0)
      on its first sample, tx_eob on its last. Between bursts the block emits
      nothing, so the sink sends nothing.

      The burst is requested by message, not by a method call, because a message
      wakes the block's thread at once: a source block that returned 0 items is
      otherwise left idle for up to 250 ms by GNU Radio's scheduler, which made the
      burst miss its start time (late packet, then an underflow per packet).

      The block's very first output is one zero sample tagged tx_eob. gr-uhd's USRP
      Sink opens a timed burst when it starts (an empty start-of-burst packet at
      now + 0.15 s) and never ends it; left open, the first real burst would close
      it with a packet whose time has passed -- a late (L) event. Ending it at once,
      well before its time, plays one zero sample and reports nothing.
      """
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, nchan=16, burst_len=32768, amp=0.25, tone_step=1.0 / 64):
              gr.sync_block.__init__(self, name="ZCU216 tone bursts", in_sig=None,
                                     out_sig=[np.complex64] * int(nchan))
              self.nchan, self.burst_len = int(nchan), int(burst_len)
              n = np.arange(self.burst_len)
              self.sig = (amp * np.exp(2j * np.pi * tone_step * n)).astype(np.complex64)
              self.message_port_register_in(pmt.intern("fire"))
              self.set_msg_handler(pmt.intern("fire"), self._fire)
              self._pending = []
              self._pos = None
              self._t0 = 0.0
              self._closed_start = False

          def _fire(self, msg):
              self._pending.append(pmt.to_double(msg))

          def work(self, input_items, output_items):
              if not self._closed_start:
                  # end gr-uhd's start-of-stream burst (see the module docstring)
                  self._closed_start = True
                  for k in range(self.nchan):
                      output_items[k][0] = 0
                  self.add_item_tag(0, self.nitems_written(0), pmt.intern("tx_eob"), pmt.PMT_T)
                  return 1
              if self._pos is None:
                  if not self._pending:
                      return 0
                  self._t0, self._pos = self._pending.pop(0), 0
              pos = self._pos
              n = min(len(output_items[0]), self.burst_len - pos)
              for k in range(self.nchan):
                  output_items[k][:n] = self.sig[pos:pos + n]
              off = self.nitems_written(0)
              if pos == 0:
                  secs = int(self._t0)
                  self.add_item_tag(0, off, pmt.intern("tx_sob"), pmt.PMT_T)
                  self.add_item_tag(0, off, pmt.intern("tx_time"),
                                    pmt.make_tuple(pmt.from_uint64(secs), pmt.from_double(self._t0 - secs)))
              if pos + n == self.burst_len:
                  self.add_item_tag(0, off + n - 1, pmt.intern("tx_eob"), pmt.PMT_T)
                  self._pos = None
              else:
                  self._pos = pos + n
              return n
    amp: '0.25'
    burst_len: burst_len
    nchan: nchan
    tone_step: tone / samp_rate
  states: {}
- name: usrp_sink
  id: uhd_usrp_sink
  parameters:
    ant0: '""'
    ant1: '""'
    ant10: '""'
    ant11: '""'
    ant12: '""'
    ant13: '""'
    ant14: '""'
    ant15: '""'
    ant2: '""'
    ant3: '""'
    ant4: '""'
    ant5: '""'
    ant6: '""'
    ant7: '""'
    ant8: '""'
    ant9: '""'
    center_freq0: freq
    center_freq1: freq
    center_freq10: freq
    center_freq11: freq
    center_freq12: freq
    center_freq13: freq
    center_freq14: freq
    center_freq15: freq
    center_freq2: freq
    center_freq3: freq
    center_freq4: freq
    center_freq5: freq
    center_freq6: freq
    center_freq7: freq
    center_freq8: freq
    center_freq9: freq
    dev_addr: dev_args
    dev_args: '""'
    gain0: tx_gain
    gain1: tx_gain
    gain10: tx_gain
    gain11: tx_gain
    gain12: tx_gain
    gain13: tx_gain
    gain14: tx_gain
    gain15: tx_gain
    gain2: tx_gain
    gain3: tx_gain
    gain4: tx_gain
    gain5: tx_gain
    gain6: tx_gain
    gain7: tx_gain
    gain8: tx_gain
    gain9: tx_gain
    nchan: nchan
    otw: sc8
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: usrp_source
  id: uhd_usrp_source
  parameters:
    ant0: '""'
    ant1: '""'
    ant10: '""'
    ant11: '""'
    ant12: '""'
    ant13: '""'
    ant14: '""'
    ant15: '""'
    ant2: '""'
    ant3: '""'
    ant4: '""'
    ant5: '""'
    ant6: '""'
    ant7: '""'
    ant8: '""'
    ant9: '""'
    center_freq0: freq
    center_freq1: freq
    center_freq10: freq
    center_freq11: freq
    center_freq12: freq
    center_freq13: freq
    center_freq14: freq
    center_freq15: freq
    center_freq2: freq
    center_freq3: freq
    center_freq4: freq
    center_freq5: freq
    center_freq6: freq
    center_freq7: freq
    center_freq8: freq
    center_freq9: freq
    dev_addr: dev_args
    dev_args: '""'
    gain0: rx_gain
    gain1: rx_gain
    gain10: rx_gain
    gain11: rx_gain
    gain12: rx_gain
    gain13: rx_gain
    gain14: rx_gain
    gain15: rx_gain
    gain2: rx_gain
    gain3: rx_gain
    gain4: rx_gain
    gain5: rx_gain
    gain6: rx_gain
    gain7: rx_gain
    gain8: rx_gain
    gain9: rx_gain
    nchan: nchan
    otw: sc8
    rx_agc10: Default
    rx_agc11: Default
    rx_agc12: Default
    rx_agc13: Default
    rx_agc14: Default
    rx_agc15: Default
    rx_agc2: Default
    rx_agc3: Default
    rx_agc4: Default
    rx_agc5: Default
    rx_agc6: Default
    rx_agc7: Default
    rx_agc8: Default
    rx_agc9: Default
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [tones, '0', usrp_sink, '0']
- [tones, '1', usrp_sink, '1']
- [tones, '10', usrp_sink, '10']
- [tones, '11', usrp_sink, '11']
- [tones, '12', usrp_sink, '12']
- [tones, '13', usrp_sink, '13']
- [tones, '14', usrp_sink, '14']
- [tones, '15', usrp_sink, '15']
- [tones, '2', usrp_sink, '2']
- [tones, '3', usrp_sink, '3']
- [tones, '4', usrp_sink, '4']
- [tones, '5', usrp_sink, '5']
- [tones, '6', usrp_sink, '6']
- [tones, '7', usrp_sink, '7']
- [tones, '8', usrp_sink, '8']
- [tones, '9', usrp_sink, '9']
- [usrp_source, '0', spec0, '0']
- [usrp_source, '0', time0, '0']
- [usrp_source, '1', spec0, '1']
- [usrp_source, '1', time0, '1']
- [usrp_source, '10', spec2, '2']
- [usrp_source, '10', time2, '2']
- [usrp_source, '11', spec2, '3']
- [usrp_source, '11', time2, '3']
- [usrp_source, '12', spec3, '0']
- [usrp_source, '12', time3, '0']
- [usrp_source, '13', spec3, '1']
- [usrp_source, '13', time3, '1']
- [usrp_source, '14', spec3, '2']
- [usrp_source, '14', time3, '2']
- [usrp_source, '15', spec3, '3']
- [usrp_source, '15', time3, '3']
- [usrp_source, '2', spec0, '2']
- [usrp_source, '2', time0, '2']
- [usrp_source, '3', spec0, '3']
- [usrp_source, '3', time0, '3']
- [usrp_source, '4', spec1, '0']
- [usrp_source, '4', time1, '0']
- [usrp_source, '5', spec1, '1']
- [usrp_source, '5', time1, '1']
- [usrp_source, '6', spec1, '2']
- [usrp_source, '6', time1, '2']
- [usrp_source, '7', spec1, '3']
- [usrp_source, '7', time1, '3']
- [usrp_source, '8', spec2, '0']
- [usrp_source, '8', time2, '0']
- [usrp_source, '9', spec2, '1']
- [usrp_source, '9', time2, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
